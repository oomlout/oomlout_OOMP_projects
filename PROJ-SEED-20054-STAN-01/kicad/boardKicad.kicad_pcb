# Repository oomlout/oomlout_OOMP_projects (continued)

## KiCad design PROJ-ARDU-MEGA-2560-01/kicad/boardKicad.kicad_pcb

File PROJ-ARDU-MEGA-2560-01/Readme.md (part):

Contents
========

* [PRAR2560 > ](#prar2560--)
	* [Schematic](#schematic)
	* [PCB](#pcb)
	* [Interactive BOM](#interactive-bom)
	* [OOMP Parts](#oomp-parts)
	* [Images](#images)
	* [Tags](#tags)
  
![][im]
# PRAR2560 > 

- ID: PROJ-ARDU-MEGA-2560-01
- Hex ID: PRAR2560
- Name: Arduino 2560 Mega
- Description: Arduino 2560 Mega
- Long Link: [http://oom.lt/PROJ-ARDU-MEGA-2560-01](http://oom.lt/PROJ-ARDU-MEGA-2560-01)
- Short Link: [http://oom.lt/PRAR2560](http://oom.lt/PRAR2560)

## Schematic

## PCB

## Interactive BOM

- Interactive BOM page: [ibom.html](https://htmlpreview.github.io/?https://github.com/oomlout/oomlout_OOMP_projects/blob/main/PROJ-ARDU-MEGA-2560-01/kicad/bom/ibom.html)

## OOMP Parts

|OOMP ID|Name|Identifier|
| :---: | :---: | :---: |
|UNMATCHED-UNMATCHED-X-UNMATCHED-01||ADCH, ADCL, COMMUNICATION, F1, GROUND, IC1, IC3, IC4, IC7, ICSP, ICSP1, POWER, PWML, RESET, RESET-EN, RN1, RN2, RN3, RN4, RN5, T1, X1, X2, XIO, Y1, Y2|
|[CAPC-0603-X-PF22-V50](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-PF22-V50/)|[SMD (0603) 22 pF Capacitor (Ceramic) 50v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-PF22-V50/)|[C1, C14, C15](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-PF22-V50/)|
|[CAPC-0603-X-NF100-V50](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-NF100-V50/)|[SMD (0603) 100 nF Capacitor (Ceramic) 50v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-NF100-V50/)|[C2, C3, C4, C5, C6, C7, C8, C9, C11, C12, C16](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-NF100-V50/)|
|[CAPC-0603-X-UF1-V25](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-UF1-V25/)|[SMD (0603) 1 uF Capacitor (Ceramic) 25v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-UF1-V25/)|[C10, C13](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0603-X-UF1-V25/)|
|DIOD-UNMATCHED-X-UNMATCHED-01||D1, D2, D3|
|UNMATCHED-SO23-X-UNMATCHED-01||IC6|
|[HEAD-I01-X-PI2X02-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI2X02-01/)|[2.54 mm 4 Pin (2x2) Header](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI2X02-01/)|[JP5](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI2X02-01/)|
|[HEAD-I01-X-PI10-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI10-01/)|[2.54 mm 10 Pin Header](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI10-01/)|[JP6](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI10-01/)|
|UNMATCHED-0805-X-UNMATCHED-01||L, L1, L2, ON, RX, TX|
|CAPE-PAND-X-UF47-01||PC1, PC2|
|[RESE-0603-X-O105-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0603-X-O105-01/)|[SMD (0603) 1M Ohm Resistor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0603-X-O105-01/)|[R1, R2](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0603-X-O105-01/)|
|UNMATCHED-0603-X-UNMATCHED-01||Z1, Z2|

## Images

|bominteractivefront|bominteractiveback|kicadPcb3d|kicadPcb3dFront|kicadPcb3dBack|kicadSchem|eagleImage|eagleSchemImage|pcbdraw|pcbdrawback|
| :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: |
|||||||||||

## Tags

- hexID: PRAR2560
- oompType: PROJ
- oompSize: ARDU
- oompColor: MEGA
- oompDesc: 2560
- oompIndex: 01
- sources: All source files from https://store.arduino.cc/collections/boards/products/arduino-mega-2560-rev3
- linkBuyPage: https://store.arduino.cc/collections/boards/products/arduino-mega-2560-rev3
- oompID: PROJ-ARDU-MEGA-2560-01
- oompParts: ADCH,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: ADCL,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: C1,CAPC-0603-X-PF22-V50
- oompParts: C2,CAPC-0603-X-NF100-V50
- oompParts: C3,CAPC-0603-X-NF100-V50
- oompParts: C4,CAPC-0603-X-NF100-V50
- oompParts: C5,CAPC-0603-X-NF100-V50
- oompParts: C6,CAPC-0603-X-NF100-V50
- oompParts: C7,CAPC-0603-X-NF100-V50
- oompParts: C8,CAPC-0603-X-NF100-V50
- oompParts: C9,CAPC-0603-X-NF100-V50
- oompParts: C10,CAPC-0603-X-UF1-V25
- oompParts: C11,CAPC-0603-X-NF100-V50
- oompParts: C12,CAPC-0603-X-NF100-V50
- oompParts: C13,CAPC-0603-X-UF1-V25
- oompParts: C14,CAPC-0603-X-PF22-V50
- oompParts: C15,CAPC-0603-X-PF22-V50
- oompParts: C16,CAPC-0603-X-NF100-V50
- oompParts: COMMUNICATION,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: D1,DIOD-UNMATCHED-X-UNMATCHED-01
- oompParts: D2,DIOD-UNMATCHED-X-UNMATCHED-01
- oompParts: D3,DIOD-UNMATCHED-X-UNMATCHED-01
- oompParts: F1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: GROUND,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: IC1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: IC3,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: IC4,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: IC6,UNMATCHED-SO23-X-UNMATCHED-01
- oompParts: IC7,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: ICSP,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: ICSP1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: JP5,HEAD-I01-X-PI2X02-01
- oompParts: JP6,HEAD-I01-X-PI10-01
- oompParts: L,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: L1,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: L2,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: ON,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: PC1,CAPE-PAND-X-UF47-01
- oompParts: PC2,CAPE-PAND-X-UF47-01
- oompParts: POWER,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: PWML,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: R1,RESE-0603-X-O105-01
- oompParts: R2,RESE-0603-X-O105-01
- oompParts: RESET,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RESET-EN,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RN1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RN2,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RN3,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RN4,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RN5,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RX,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: T1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: TX,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: X1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: X2,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: XIO,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: Y1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: Y2,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: Z1,UNMATCHED-0603-X-UNMATCHED-01
- oompParts: Z2,UNMATCHED-0603-X-UNMATCHED-01
- rawParts: ADCH,FH254-108DF08500V,0058_FH254-108DF08500V,1X08,Female Connector strip for Arduino bases - 8x1 F V h 8,5 p2,54mm,,,,,,,,_____,,FH254-108DF08500V,_____,_____,Connettori,FH254-108DF08500V,
- rawParts: ADCL,FH254-108DF08500V,0058_FH254-108DF08500V,1X08,Female Connector strip for Arduino bases - 8x1 F V h 8,5 p2,54mm,,,,,,,,_____,,FH254-108DF08500V,_____,_____,Connettori,FH254-108DF08500V,
- rawParts: C1,22p,0014_22PF_0603,C0603-ROUND,22pF 0603,0603,,,,,,,_____,,22pF_0603,_____,_____,Condensatori,22p,
- rawParts: C2,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C3,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C4,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C5,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C6,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C7,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C8,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
- rawParts: C9,100nF,0015_100NF_0603,C0603-ROUND,100nF 0603 50V,0603,,,,,,,_____,,cl10b104kbnc,_____,_____,Condensatori,100nF,
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
Board: 2 copper layers, 101.6 x 53.3 mm, 72 parts (1 on the bottom side), 111 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3, @HOLE4, @HOLE5: (no value)
ADCH0: FH254-108DF08500V; 1X08
ADCL0: FH254-108DF08500V; 1X08
C1, C14, C15: 22p; C0603-ROUND
C2, C3, C4, C5, C6, C7, C8, C9, C11, C12, C16: 100nF; C0603-ROUND
C10, C13: 1uF; C0603-ROUND
COMMUNICATION0: FH254-108DF08500V; 1X08
D1: M7; SMB
D2, D3: CD1206-S01575; MINIMELF
F1: MF-MSMF050-2 500mA; L1812
FD1, FD2, FD3, FD4: FIDUCIALMOUNT; FIDUCIA-MOUNT
GROUND0: SJ
IC1: 1870_LD1117S50CTR; LINEAR_SOT223
IC3: ATMEGA2560-15AU; TQFP100
IC4: ATMEGA16U2-MU; MLF32
IC6: LP2985-33DBVR; SOT23-DBV
IC7: LMV358IDGKR; MSOP08
ICSP0, ICSP1: ICSP; 2X03
JP5: 2x2M - NM; 2X02
JP6: FH254-110DF08500V; 1X10
L0: Yellow; CHIPLED_0805
L1: MH2029-300Y; 0805
L2: 10uH; 0805
ON0: Green; CHIPLED_0805
PC1, PC2: 47uF; PANASONIC_D
POWER0: FH254-108DF08500V; 1X08
PWML0: FH254-108DF08500V; 1X08
R1, R2: 1M; R0603-ROUND
RESET0: TS42
RESET-EN0: SJ
RN1, RN5: 10k; CAY16
RN2: 22R; CAY16
RN3, RN4: 1K; CAY16
RX0: Yellow; CHIPLED_0805
T1: PMV48XP; SOT-23
TX0: Yellow; CHIPLED_0805
U$1, U$2: DNP; FRAME
X1: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
X2: PN61729
XIO0: 18x2F-H8.5; 2X18
Y1: CSTCE16M0V53-R0; RESONATOR
Y2: 16MHz; QS
Z1, Z2: BRNCG0603MLC-05E; CT_CN0603

Connections:
8PB4: IC4.18, JP5.1
8PB5: IC4.19, JP5.3
8PB6: IC4.20, JP5.2
8PB7: IC4.21, JP5.4
+3V3: C13.2, IC6.5, IC7.6, POWER0.4
+5V: C4.1, C5.1, C6.1, C9.1, C11.2, D2.C, D3.C, IC1.2, IC1.4, IC3.10, IC3.31, IC3.61, IC3.80, IC4.4, IC4.32, IC6.1, IC6.3, IC7.8, ICSP0.2, ICSP1.2, L2.2, PC2.+, POWER0.2, POWER0.5, RN1.6, RN1.7, RN3.1, RN4.5, RN4.6, RN5.2, RN5.8, T1.2, XIO0.1, XIO0.2
ADC0: ADCL0.1, IC3.97
ADC1: ADCL0.2, IC3.96
ADC2: ADCL0.3, IC3.95
ADC3: ADCL0.4, IC3.94
ADC4: ADCL0.5, IC3.93
ADC5: ADCL0.6, IC3.92
ADC6: ADCL0.7, IC3.91
ADC7: ADCL0.8, IC3.90
ADC8: ADCH0.1, IC3.89
ADC9: ADCH0.2, IC3.88
ADC10: ADCH0.3, IC3.87
ADC11: ADCH0.4, IC3.86
ADC12: ADCH0.5, IC3.85
ADC13: ADCH0.6, IC3.84
ADC14: ADCH0.7, IC3.83
ADC15: ADCH0.8, IC3.82
AREF: C3.1, IC3.98, JP6.3
AVCC: C16.1, IC3.100, L2.1
CMP: C12.2, IC7.5, RN5.3, RN5.5
D+: RN2.5, X2.3, Z2.2
D-: RN2.8, X2.2, Z1.2
DTR: C7.1, IC4.13, RN3.4
GATE_CMD: IC7.7, T1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C11.1, C12.1, C13.1, C14.2, C15.2, C16.2, GROUND0.2, IC1.1, IC3.11, IC3.32, IC3.62, IC3.81, IC3.99, IC4.3, IC4.33, IC6.2, IC7.4, ICSP0.6, ICSP1.6, JP6.4, L0.C, ON0.C, PC1.-, PC2.-, POWER0.6, POWER0.7, RESET0.1, RESET0.2, RN3.5, RN5.4, X1.1, X1.3, XIO0.35, XIO0.36, Y1.2
L13: IC7.1, IC7.2, RN3.7
M8RXD: IC4.9, RN4.7
M8TXD: IC4.8, RN4.8
MISO2: IC4.17, ICSP1.1
MOSI2: IC4.16, ICSP1.4
unnamed: L0.A, RN3.2
unnamed: ON0.A, RN3.8
unnamed: RN4.4, RX0.A
unnamed: RN4.3, TX0.A
PA0: IC3.78, XIO0.3
PA1: IC3.77, XIO0.4
PA2: IC3.76, XIO0.5
PA3: IC3.75, XIO0.6
PA4: IC3.74, XIO0.7
PA5: IC3.73, XIO0.8
PA6: IC3.72, XIO0.9
PA7: IC3.71, XIO0.10
PB0: IC3.19, XIO0.34
PB1: IC3.20, ICSP0.3, XIO0.33
PB2: IC3.21, ICSP0.4, XIO0.32
PB3: IC3.22, ICSP0.1, XIO0.31
PB4: IC3.23, JP6.8
PB5: IC3.24, JP6.7
PB6: IC3.25, JP6.6
PB7: IC3.26, IC7.3, JP6.5
PC0: IC3.53, XIO0.18
PC1: IC3.54, XIO0.17
PC2: IC3.55, XIO0.16
PC3: IC3.56, XIO0.15
PC4: IC3.57, XIO0.14
PC5: IC3.58, XIO0.13
PC6: IC3.59, XIO0.12
PC7: IC3.60, XIO0.11
PD7: IC3.50, XIO0.19
PE0: IC3.2, PWML0.1, RN4.2
PE1: IC3.3, PWML0.2, RN4.1
PE3: IC3.5, PWML0.6
PE4: IC3.6, PWML0.3
PE5: IC3.7, PWML0.4
PG0: IC3.51, XIO0.22
PG1: IC3.52, XIO0.21
PG2: IC3.70, XIO0.20
PG5: IC3.1, PWML0.5
PH3: IC3.15, PWML0.7
PH4: IC3.16, PWML0.8
PH5: IC3.17, JP6.10
PH6: IC3.18, JP6.9
PL0: IC3.35, XIO0.30
PL1: IC3.36, XIO0.29
PL2: IC3.37, XIO0.28
PL3: IC3.38, XIO0.27
PL4: IC3.39, XIO0.26
PL5: IC3.40, XIO0.25
PL6: IC3.41, XIO0.24
PL7: IC3.42, XIO0.23
PWRIN: D1.A, X1.2
RD+: IC4.29, RN2.4
RD-: IC4.30, RN2.1
RESET: C1.1, C7.2, D3.A, IC3.30, ICSP0.5, POWER0.3, RESET0.3, RESET0.4, RESET-EN0.1, RESET-EN0.2, RN5.1
RESET2: D2.A, IC4.24, ICSP1.5, RN5.7
RXD1: COMMUNICATION0.3, IC3.45
RXD2: COMMUNICATION0.5, IC3.12
RXD3: COMMUNICATION0.7, IC3.63
RXL: IC4.10, RX0.C
SCK2: IC4.15, ICSP1.3
SCL: COMMUNICATION0.1, IC3.43, JP6.1, RN1.2
SDA: COMMUNICATION0.2, IC3.44, JP6.2, RN1.3
TXD1: COMMUNICATION0.4, IC3.46
TXD2: COMMUNICATION0.6, IC3.13
TXD3: COMMUNICATION0.8, IC3.64
TXL: IC4.11, TX0.C
UGND: C10.2, GROUND0.1, IC4.28, L1.1, X2.4
USBVCC: C8.1, F1.1, IC4.31, T1.1
USHIELD: L1.2, X2.P$1, X2.P$2, Z1.1, Z2.1
VIN: C2.1, D1.C, IC1.3, PC1.+, POWER0.8, RN5.6
VUCAP: C10.1, IC4.27
XT1: C14.1, IC4.1, R2.1, Y2.2
XT2: C15.1, IC4.2, R2.2, Y2.1
XTAL1: IC3.34, R1.1, Y1.3
XTAL2: IC3.33, R1.2, Y1.1
XVCC: F1.2, X2.1

File PROJ-ARDU-MEGA-2560-01/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"ICSP1,ICSP0";"2X03";2;"ICSP";;;
2;"ADCH0,COMMUNICATION0,ADCL0,POWER0,PWML0";"1X08";5;"FH254-108DF08500V";;;
3;"IC1";"LINEAR_SOT223";1;"1870_LD1117S50CTR";;;
4;"RESET-EN0,GROUND0";"SJ";2;"";;;
5;"FD1,FD3,FD4,FD2";"FIDUCIA-MOUNT";4;"FIDUCIALMOUNT";;;
6;"XIO0";"2X18";1;"18x2F-H8.5";;;
7;"C1,C15,C14";"C0603-ROUND";3;"22p";;;
8;"PC2,PC1";"PANASONIC_D";2;"47uF";;;
9;"Z2,Z1";"CT_CN0603";2;"BRNCG0603MLC-05E";;;
10;"JP6";"1X10";1;"FH254-110DF08500V";;;
11;"R1,R2";"R0603-ROUND";2;"1M";;;
12;"Y1";"RESONATOR";1;"CSTCE16M0V53-R0";;;
13;"IC4";"MLF32";1;"ATMEGA16U2-MU";;;
14;"C3,C9,C16,C4,C7,C2,C12,C8,C11,C5,C6";"C0603-ROUND";11;"100nF";;;
15;"RN3,RN4";"CAY16";2;"1K";;;
16;"L1";"0805";1;"MH2029-300Y";;;
17;"T1";"SOT-23";1;"PMV48XP";;;
18;"U$1,U$2";"FRAME";2;"DNP";;;
19;"@HOLE4,@HOLE3,@HOLE1,@HOLE2,@HOLE0,@HOLE5";"";6;"";;;
20;"C13,C10";"C0603-ROUND";2;"1uF";;;
21;"IC6";"SOT23-DBV";1;"LP2985-33DBVR";;;
22;"JP5";"2X02";1;"2x2M - NM";;;
23;"D1";"SMB";1;"M7";;;
24;"Y2";"QS";1;"16MHz";;;
25;"IC3";"TQFP100";1;"ATMEGA2560-15AU";;;
26;"ON0";"CHIPLED_0805";1;"Green";;;
27;"IC7";"MSOP08";1;"LMV358IDGKR";;;
28;"D3,D2";"MINIMELF";2;"CD1206-S01575";;;
29;"X1";"POWERSUPPLY_DC-21MM";1;"POWERSUPPLY_DC21MMX";;;
30;"RN5,RN1";"CAY16";2;"10k";;;
31;"RX0,TX0,L0";"CHIPLED_0805";3;"Yellow";;;
32;"F1";"L1812";1;"MF-MSMF050-2 500mA";;;
33;"X2";"PN61729";1;"";;;
34;"L2";"0805";1;"10uH";;;
35;"RN2";"CAY16";1;"22R";;;
36;"RESET0";"TS42";1;"TS42";;;

## KiCad design PROJ-ARDU-UNO-REV3-SM/kicad/boardKicad.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 76 parts (1 on the bottom side), 61 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
C1, C2, C4, C5, C6, C7: 100n; C0603-ROUND
C3, C8: 1u; C0603-ROUND
C9, C11: 22p; C0603-ROUND
C10: 100nF; C0603-ROUND
D1: M7; SMB
D2, D3: CD1206-S01575; MINIMELF
F1: MF-MSMF050-2 500mA; L1812
FD1, FD2, FD3: DNP; FD-1-1.5
FRAME1: DNP; FRAME
GROUND0: SJ
ICSP0, ICSP1: 3x2 M; 2X03
J1: -; 1X14-CUSTOM
J2: -; 1X18-CUSTOM
JP2: 2x2 M-NM; 2X02
L0: YELLOW; CHIP-LED0805
L1: BLM21; 0805
L2: 10uH; 0805
ON0: GREEN; CHIP-LED0805
ORIGIN0: TP_SP; TP-SP
PC1, PC2: 47u; PANASONIC_D
R1, R2: 1M; R0603-ROUND
RESET0: TS42031-160R-TR-7260; TS42
RESET-EN0: SJ
RN1: 10K; CAY16
RN2, RN4: 1K; CAY16
RN3: 22R; CAY16
RX0: YELLOW; CHIP-LED0805
T1: FDN340P; SOT-23
TP_5V1: TP_SP; TP-SP
TP_CMP0: TP_SP; TP-SP
TP_DTR0: TP_SP; TP-SP
TP_GATE0: TP_SP; TP-SP
TP_LCMD0: TP_SP; TP-SP
TP_LL0: TP_SP; TP-SP
TP_MISO2: TP_SP; TP-SP
TP_MOSI2: TP_SP; TP-SP
TP_ONL0: TP_SP; TP-SP
TP_RESET2: TP_SP; TP-SP
TP_RX0: TP_SP; TP-SP
TP_RXL0: TP_SP; TP-SP
TP_SCK2: TP_SP; TP-SP
TP_TX0: TP_SP; TP-SP
TP_TXL0: TP_SP; TP-SP
TP_USBVCC0: TP_SP; TP-SP
TP_USH0: TP_SP; TP-SP
TP_VUCAP0: TP_SP; TP-SP
TX0: YELLOW; CHIP-LED0805
U1: NCP1117ST50T3G; SOT223
U2: LP2985-33DBVR; SOT23-DBV
U3: 16U2; ATMEL_QFN32
U4: ATMEGA328P-MU; MLF32
U5: LMV358IDGKR; MSOP08
X1: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
X2: USB-B_TH; PN61729
Y1: 16MHz; QS
Y2: CSTCE16M0V53-R0 16MHZ; RESONATOR
Z1, Z2: CG0603MLC-05E; CT_CN0603

Connections:
+3V3: C3.2, J1.4, U2.5, U5.2
+5V: C1.2, C2.2, C6.2, C7.1, D2.C, D3.C, ICSP0.2, ICSP1.2, J1.2, J1.5, L2.1, PC2.+, RN1.3, RN1.5, RN2.2, RN2.3, RN4.3, RN4.4, T1.2, TP_5V1.X, U1.2, U1.4, U2.1, U2.3, U3.4, U3.32, U4.4, U4.6, U5.8
A0: J1.9, U4.23
A1: J1.10, U4.24
A2: J1.11, U4.25
A3: J1.12, U4.26
A4/SDA: J1.13, J2.17, U4.27
A5/SCL: J1.14, J2.18, U4.28
AREF: C4.2, J2.16, U4.20
CMP: RN1.1, RN1.2, TP_CMP0.X, U5.3
D+: RN3.5, X2.3, Z1.1
D-: RN3.8, X2.2, Z2.1
DTR: C5.1, RN2.4, TP_DTR0.X, U3.13
GATE_CMD: T1.3, TP_GATE0.X, U5.1
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.2, C9.2, C10.2, C11.2, GROUND0.1, ICSP0.6, ICSP1.6, J1.6, J1.7, J2.15, L0.C, ON0.C, PC1.-, PC2.-, RESET0.1, RESET0.2, RN1.7, RN2.5, U1.1, U2.2, U3.3, U3.EXP, U4.3, U4.5, U4.21, U5.4, X1.1, X1.3, Y2.2
IO0: J2.1, RN4.2, U4.30
IO1: J2.2, RN4.1, U4.31
IO2: J2.3, U4.32
IO3: J2.4, U4.1
IO4: J2.5, U4.2
IO5: J2.6, U4.9
IO6: J2.7, U4.10
IO7: J2.8, U4.11
IO8: J2.9, U4.12
IO9: J2.10, U4.13
L13: RN2.8, TP_LCMD0.X, U5.6, U5.7
M8RXD: RN4.7, TP_RX0.X, U3.9
M8TXD: RN4.8, TP_TX0.X, U3.8
MISO: ICSP0.1, J2.13, U4.16
MISO2: ICSP1.1, TP_MISO2.X, U3.17
MOSI: ICSP0.4, J2.12, U4.15
MOSI2: ICSP1.4, TP_MOSI2.X, U3.16
unnamed: L0.A, RN2.1, TP_LL0.X
unnamed: ON0.A, RN4.5, RN4.6, TP_ONL0.X
unnamed: C10.1, L2.2, U4.18
unnamed: RN2.7, RX0.A, TP_RXL0.X
unnamed: RN2.6, TP_TXL0.X, TX0.A
PB4: JP2.1, U3.18
PB5: JP2.3, U3.19
PB6: JP2.2, U3.20
PB7: JP2.4, U3.21
PWRIN: D1.A, X1.2
RD+: RN3.4, U3.29
RD-: RN3.1, U3.30
RESET: C5.2, D2.A, ICSP0.5, J1.3, RESET0.3, RESET0.4, RESET-EN0.1, RESET-EN0.2, RN1.4, U4.29
RESET2: D3.A, ICSP1.5, RN1.6, TP_RESET2.X, U3.24
RXLED: RX0.C, U3.10
SCK: ICSP0.3, J2.14, U4.17, U5.5
SCK2: ICSP1.3, TP_SCK2.X, U3.15
SS: J2.11, U4.14
TP_VUCAP: C8.1, TP_VUCAP0.X, U3.27
TXLED: TX0.C, U3.11
UGND: C8.2, GROUND0.2, L1.1, U3.28, X2.4
USBVCC: F1.1, T1.1, TP_USBVCC0.X, U3.31
USHIELD: L1.2, TP_USH0.X, X2.P$1, X2.P$2, Z1.2, Z2.2
VIN: D1.C, J1.8, PC1.+, RN1.8, U1.3
XT1: C9.1, R1.1, U3.1, Y1.2
XT2: C11.1, R1.2, U3.2, Y1.1
XTAL1: R2.1, U4.7, Y2.3
XTAL2: R2.2, U4.8, Y2.1
XUSB: F1.2, X2.1

File PROJ-ARDU-UNO-REV3-SM/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"TP_LL0,TP_ONL0,TP_USH0,TP_GATE0,TP_5V1,TP_RESET2,TP_LCMD0,TP_MOSI2,TP_RXL0,TP_TXL0,TP_TX0,TP_USBVCC0,ORIGIN0,TP_VUCAP0,TP_MISO2,TP_DTR0,TP_RX0,TP_SCK2,TP_CMP0";"TP-SP";19;"TP_SP";;;
2;"RX0,L0,TX0";"CHIP-LED0805";3;"YELLOW";;;
3;"Z1,Z2";"CT_CN0603";2;"CG0603MLC-05E";;;
4;"D2,D3";"MINIMELF";2;"CD1206-S01575";;;
5;"C6,C2,C4,C5,C7,C1";"C0603-ROUND";6;"100n";;;
6;"@HOLE2,@HOLE3,@HOLE0,@HOLE1";"";4;"";;;
7;"RN3";"CAY16";1;"22R";;;
8;"J2";"1X18-CUSTOM";1;"-";;;
9;"U4";"MLF32";1;"ATMEGA328P-MU";;;
10;"U5";"MSOP08";1;"LMV358IDGKR";;;
11;"RESET-EN0,GROUND0";"SJ";2;"";;;
12;"FD1,FD2,FD3";"FD-1-1.5";3;"DNP";;;
13;"RN2,RN4";"CAY16";2;"1K";;;
14;"RESET0";"TS42";1;"TS42031-160R-TR-7260";;;
15;"Y1";"QS";1;"16MHz";;;
16;"T1";"SOT-23";1;"FDN340P";;;
17;"Y2";"RESONATOR";1;"CSTCE16M0V53-R0 16MHZ";;;
18;"R2,R1";"R0603-ROUND";2;"1M";;;
19;"L2";"0805";1;"10uH";;;
20;"X1";"POWERSUPPLY_DC-21MM";1;"POWERSUPPLY_DC21MMX";;;
21;"C3,C8";"C0603-ROUND";2;"1u";;;
22;"L1";"0805";1;"BLM21";;;
23;"F1";"L1812";1;"MF-MSMF050-2 500mA";;;
24;"X2";"PN61729";1;"USB-B_TH";;;
25;"RN1";"CAY16";1;"10K";;;
26;"C9,C11";"C0603-ROUND";2;"22p";;;
27;"U3";"ATMEL_QFN32";1;"16U2";;;
28;"ICSP0,ICSP1";"2X03";2;"3x2 M";;;
29;"D1";"SMB";1;"M7";;;
30;"J1";"1X14-CUSTOM";1;"-";;;
31;"ON0";"CHIP-LED0805";1;"GREEN";;;
32;"FRAME1";"FRAME";1;"DNP";;;
33;"U1";"SOT223";1;"NCP1117ST50T3G";;;
34;"JP2";"2X02";1;"2x2 M-NM";;;
35;"C10";"C0603-ROUND";1;"100nF";;;
36;"U2";"SOT23-DBV";1;"LP2985-33DBVR";;;
37;"PC2,PC1";"PANASONIC_D";2;"47u";;;

## KiCad design PROJ-ARDU-UNO-REV3-01/kicad/boardKicad.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 120 parts (1 on the bottom side), 61 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
AD0: 6x1F-H8.5; 1X06
C1, C2, C4, C5, C6, C7, C10: 100n; C0603-ROUND
C3, C8: 1u; C0603-ROUND
C9, C11: 22p; C0603-ROUND
D1: M7; SMB
D2, D3: CD1206-S01575; MINIMELF
F1: MF-MSMF050-2 500mA; L1812
FD1, FD2, FD3: FIDUCIALMOUNT; FIDUCIA-MOUNT
FRAME1: DNP; FRAME
GND_TP0, GND_TP1: TP_SP; TP-SP
GROUND0: SJ
ICSP0, ICSP1: 3x2 M; 2X03
IOH0: 10x1F-H8.5; 1X10
IOL0: 8x1F-H8.5; 1X08
JP2: 2x2 M - NM; 2X02
L0: YELLOW; CHIP-LED0805
L1: BLM21; 0805
L2: 10uH; 0805
ON0: GREEN; CHIP-LED0805
ORIGIN0: TP_SP; TP-SP
PC1, PC2: 47u; PANASONIC_D
POWER0: 8x1F-H8.5; 1X08
R1, R2: 1M; R0603-ROUND
RESET0: TS42031-160R-TR-7260; TS42
RESET-EN0: SJ
RN1: 10K; CAY16
RN2, RN4: 1K; CAY16
RN3: 22R; CAY16
RX0: YELLOW; CHIP-LED0805
T1: FDN340P; SOT-23
TP_0, TP_1, TP_2, TP_3, TP_3V3, TP_4, TP_5, TP_5V0, TP_5V1, TP_6, TP_7, TP_8, TP_9, TP_10, TP_11, TP_12, TP_13: TP_SP; TP-SP
TP_A0, TP_A1, TP_A2, TP_A3, TP_A4, TP_A5: TP_SP; TP-SP
TP_AREF0: TP_SP; TP-SP
TP_CMP0: TP_SP; TP-SP
TP_D+0: TP_SP; TP-SP
TP_D-0: TP_SP; TP-SP
TP_DTR0: TP_SP; TP-SP
TP_GATE0: TP_SP; TP-SP
TP_LCMD0: TP_SP; TP-SP
TP_LL0: TP_SP; TP-SP
TP_MISO2: TP_SP; TP-SP
TP_MOSI2: TP_SP; TP-SP
TP_ONL0: TP_SP; TP-SP
TP_PB4, TP_PB5, TP_PB6, TP_PB7: TP_SP; TP-SP
TP_PWRIN0: TP_SP; TP-SP
TP_RESET0, TP_RESET2: TP_SP; TP-SP
TP_RX0: TP_SP; TP-SP
TP_RXL0: TP_SP; TP-SP
TP_SCK2: TP_SP; TP-SP
TP_SCL0: TP_SP; TP-SP
TP_SDA0: TP_SP; TP-SP
TP_TX0: TP_SP; TP-SP
TP_TXL0: TP_SP; TP-SP
TP_UGND0: TP_SP; TP-SP
TP_USBVCC0: TP_SP; TP-SP
TP_USH0: TP_SP; TP-SP
TP_VIN0: TP_SP; TP-SP
TP_VUCAP0: TP_SP; TP-SP
TP_XT1, TP_XT2, TP_XT3, TP_XT4: TP_SP; TP-SP
TP_XUSB0: TP_SP; TP-SP
TX0: YELLOW; CHIP-LED0805
U1: NCP1117ST50T3G; SOT223
U2: LP2985-33DBVR; SOT23-DBV
U3: ATMEGA16U2-MU(R); MLF32
U5: LMV358IDGKR; MSOP08
X1: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
X2: USB-B_TH; PN61729
Y1: 16MHz; QS
Y2: CSTCE16M0V53-R0 16MHZ; RESONATOR
Z1, Z2: CG0603MLC-05E; CT_CN0603
ZU4: ATMEGA328P-PU; DIL28-3

Connections:
+3V3: C3.2, POWER0.4, TP_3V3.X, U2.5, U5.2
+5V: C1.2, C2.2, C6.2, C7.1, D2.C, D3.C, ICSP0.2, ICSP1.2, L2.1, PC2.+, POWER0.2, POWER0.5, RN1.3, RN1.5, RN2.2, RN2.3, RN4.3, RN4.4, T1.2, TP_5V0.X, TP_5V1.X, U1.2, U1.4, U2.1, U2.3, U3.4, U3.32, U5.8, ZU4.7
AD0: AD0.1, TP_A0.X, ZU4.23
AD1: AD0.2, TP_A1.X, ZU4.24
AD2: AD0.3, TP_A2.X, ZU4.25
AD3: AD0.4, TP_A3.X, ZU4.26
AD4/SDA: AD0.5, IOH0.9, TP_A4.X, TP_SDA0.X, ZU4.27
AD5/SCL: AD0.6, IOH0.10, TP_A5.X, TP_SCL0.X, ZU4.28
AREF: C4.2, IOH0.8, TP_AREF0.X, ZU4.21
AVCC: C10.2, L2.2, ZU4.20
CMP: RN1.1, RN1.2, TP_CMP0.X, U5.3
D+: RN3.5, TP_D+0.X, X2.3, Z1.1
D-: RN3.8, TP_D-0.X, X2.2, Z2.1
DTR: C5.1, RN2.4, TP_DTR0.X, U3.13
GATE_CMD: T1.3, TP_GATE0.X, U5.1
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.2, C9.2, C10.1, C11.2, GND_TP0.X, GND_TP1.X, GROUND0.1, ICSP0.6, ICSP1.6, IOH0.7, L0.C, ON0.C, PC1.-, PC2.-, POWER0.6, POWER0.7, RESET0.1, RESET0.2, RN1.7, RN2.5, U1.1, U2.2, U3.3, U3.33, U5.4, X1.1, X1.3, Y2.2, ZU4.8, ZU4.22
IO0: IOL0.1, RN4.2, TP_0.X, ZU4.2
IO1: IOL0.2, RN4.1, TP_1.X, ZU4.3
IO2: IOL0.3, TP_2.X, ZU4.4
IO3: IOL0.4, TP_3.X, ZU4.5
IO4: IOL0.5, TP_4.X, ZU4.6
IO5: IOL0.6, TP_5.X, ZU4.11
IO6: IOL0.7, TP_6.X, ZU4.12
IO7: IOL0.8, TP_7.X, ZU4.13
IO8: IOH0.1, TP_8.X, ZU4.14
IO9: IOH0.2, TP_9.X, ZU4.15
L13: RN2.8, TP_LCMD0.X, U5.6, U5.7
M8RXD: RN4.7, TP_RX0.X, U3.9
M8TXD: RN4.8, TP_TX0.X, U3.8
MISO: ICSP0.1, IOH0.5, TP_12.X, ZU4.18
MISO2: ICSP1.1, TP_MISO2.X, U3.17
MOSI: ICSP0.4, IOH0.4, TP_11.X, ZU4.17
MOSI2: ICSP1.4, TP_MOSI2.X, U3.16
unnamed: L0.A, RN2.1, TP_LL0.X
unnamed: ON0.A, RN4.5, RN4.6, TP_ONL0.X
unnamed: RN2.7, RX0.A, TP_RXL0.X
unnamed: RN2.6, TP_TXL0.X, TX0.A
PB4: JP2.1, TP_PB4.X, U3.18
PB5: JP2.3, TP_PB5.X, U3.19
PB6: JP2.2, TP_PB6.X, U3.20
PB7: JP2.4, TP_PB7.X, U3.21
PWRIN: D1.A, TP_PWRIN0.X, X1.2
RD+: RN3.4, U3.29
RD-: RN3.1, U3.30
RESET: C5.2, D2.A, ICSP0.5, POWER0.3, RESET0.3, RESET0.4, RESET-EN0.1, RESET-EN0.2, RN1.4, TP_RESET0.X, ZU4.1
RESET2: D3.A, ICSP1.5, RN1.6, TP_RESET2.X, U3.24
RXLED: RX0.C, U3.10
SCK: ICSP0.3, IOH0.6, TP_13.X, U5.5, ZU4.19
SCK2: ICSP1.3, TP_SCK2.X, U3.15
SS: IOH0.3, TP_10.X, ZU4.16
TP_VUCAP: C8.1, TP_VUCAP0.X, U3.27
TXLED: TX0.C, U3.11
UGND: C8.2, GROUND0.2, L1.1, TP_UGND0.X, U3.28, X2.4
USBVCC: F1.1, T1.1, TP_USBVCC0.X, U3.31
USHIELD: L1.2, TP_USH0.X, X2.P$1, X2.P$2, Z1.2, Z2.2
VIN: D1.C, PC1.+, POWER0.8, RN1.8, TP_VIN0.X, U1.3
XT1: C9.1, R1.1, TP_XT3.X, U3.1, Y1.2
XT2: C11.1, R1.2, TP_XT4.X, U3.2, Y1.1
XTAL1: R2.1, TP_XT1.X, Y2.3, ZU4.9
XTAL2: R2.2, TP_XT2.X, Y2.1, ZU4.10
XUSB: F1.2, TP_XUSB0.X, X2.1

File PROJ-ARDU-UNO-REV3-01/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"TP_XT2,TP_PB6,TP_RX0,GND_TP0,TP_A3,TP_PB4,TP_6,TP_PB5,GND_TP1,TP_XT1,TP_PB7,TP_8,TP_RXL0,TP_10,TP_VUCAP0,TP_XT4,TP_UGND0,TP_TXL0,TP_SCL0,TP_XUSB0,TP_9,TP_PWRIN0,TP_MOSI2,TP_RESET2,TP_A0,TP_GATE0,TP_5V0,TP_5,TP_USBVCC0,TP_CMP0,TP_XT3,TP_USH0,TP_3V3,TP_7,TP_2,TP_12,TP_TX0,TP_SCK2,TP_5V1,TP_3,TP_13,TP_RESET0,TP_SDA0,TP_AREF0,TP_DTR0,TP_ONL0,TP_0,TP_D+0,TP_A2,TP_11,TP_A4,TP_A5,TP_MISO2,TP_LL0,TP_LCMD0,TP_D-0,ORIGIN0,TP_VIN0,TP_1,TP_A1,TP_4";"TP-SP";61;"TP_SP";;;
2;"FRAME1";"FRAME";1;"DNP";;;
3;"Y1";"QS";1;"16MHz";;;
4;"C11,C9";"C0603-ROUND";2;"22p";;;
5;"RN1";"CAY16";1;"10K";;;
6;"C1,C10,C6,C5,C4,C7,C2";"C0603-ROUND";7;"100n";;;
7;"T1";"SOT-23";1;"FDN340P";;;
8;"IOH0";"1X10";1;"10x1F-H8.5";;;
9;"U2";"SOT23-DBV";1;"LP2985-33DBVR";;;
10;"@HOLE2,@HOLE1,@HOLE0,@HOLE3";"";4;"";;;
11;"Z1,Z2";"CT_CN0603";2;"CG0603MLC-05E";;;
12;"D3,D2";"MINIMELF";2;"CD1206-S01575";;;
13;"U5";"MSOP08";1;"LMV358IDGKR";;;
14;"ICSP1,ICSP0";"2X03";2;"3x2 M";;;
15;"PC1,PC2";"PANASONIC_D";2;"47u";;;
16;"L0,TX0,RX0";"CHIP-LED0805";3;"YELLOW";;;
17;"RESET-EN0,GROUND0";"SJ";2;"";;;
18;"RN3";"CAY16";1;"22R";;;
19;"FD3,FD2,FD1";"FIDUCIA-MOUNT";3;"FIDUCIALMOUNT";;;
20;"L1";"0805";1;"BLM21";;;
21;"U3";"MLF32";1;"ATMEGA16U2-MU(R)";;;
22;"R1,R2";"R0603-ROUND";2;"1M";;;
23;"X1";"POWERSUPPLY_DC-21MM";1;"POWERSUPPLY_DC21MMX";;;
24;"RN4,RN2";"CAY16";2;"1K";;;
25;"C3,C8";"C0603-ROUND";2;"1u";;;
26;"ZU4";"DIL28-3";1;"ATMEGA328P-PU";;;
27;"ON0";"CHIP-LED0805";1;"GREEN";;;
28;"X2";"PN61729";1;"USB-B_TH";;;
29;"RESET0";"TS42";1;"TS42031-160R-TR-7260";;;
30;"L2";"0805";1;"10uH";;;
31;"AD0";"1X06";1;"6x1F-H8.5";;;
32;"F1";"L1812";1;"MF-MSMF050-2 500mA";;;
33;"JP2";"2X02";1;"2x2 M - NM";;;
34;"Y2";"RESONATOR";1;"CSTCE16M0V53-R0 16MHZ";;;
35;"IOL0,POWER0";"1X08";2;"8x1F-H8.5";;;
36;"U1";"SOT223";1;"NCP1117ST50T3G";;;
37;"D1";"SMB";1;"M7";;;

## Commit log

2022-06-14 Initial commit.
2022-06-20 New Readme.
2022-06-21 Added github harvest script and json file.
2022-07-24 Added a couple of projects.
2022-08-03 A few readme updates.
2022-08-03 Added sparkfun projects to project folder.
2022-08-03 Updated Sparkfun Projects.
2022-08-03 Added adafruit projects.
2022-08-03 Added a few more adafruit projects
2022-08-03 Added reeadme's and jsons
2022-08-03 Added new designs.
2022-08-03 A few more projects added.
2022-08-03 First try at auto generating eagle output.
2022-08-12 Exporting extra project files (through kicad)
2022-08-12 Readmes.
2022-08-14 Generated interactive BOMs.
2022-08-15 Added resolutions.
2022-08-15 added eagleIMage resolutions and fixed adafruit project oompNames.
2022-08-15 New readme's!
2022-08-17 Added pin details.
2022-08-17 Kicad bits added.
2022-08-17 First run through of part matching.
2022-08-18 Added oompParts
2022-08-21 File gen run through.
2022-08-21 Generated python parts lists.
2022-08-21 Readme test.
2022-08-21 A bit of kicad harvesting and fixed rawparts.
2022-08-21 Fixed +/- in part lists.
2022-08-21 Added parts table to readme.
2022-08-22 Finished harvesting kicad projects.
2022-08-22 Interactive boms updated.
2022-08-22 Redid part matching.
2022-08-22 A few final part changes.
2022-08-22 Image resolutions.
2022-08-23 Another parts matching run.
2022-08-23 Extra parts.
2022-08-23 New readme's and jsons.
2022-08-24 Readme's redone.
2022-08-24 Redid jsons.
2022-09-02 Project readme's sorted.
2022-09-04 Harvested schematic files for projects (some)
2022-09-04 New part files.
2022-09-04 Part file update.
2022-09-05 Change in part matching.
2022-09-06 Schematic grab finished?
2022-09-07 Added a few images and readme fixups.
2022-09-09 Higher resolution Schematics.
2022-09-10 Fixed schematic image. and updated readme.
2022-09-13 Fixed short link in readme.
2022-09-19 Attempt at part matching.
2022-09-19 Fixed up parts matching.
2022-09-21 Work on OOMP part matching.
2022-09-22 Did capacitor voltage matching.
2022-09-22 Better part representation in readme.
2022-09-22 fixing
2022-09-24 Fixed a part coding error.
2022-09-24 Part Matching refresh.
2022-09-25 A few extra details
2022-10-06 pcbdraw resolutions.
2022-10-06 Added SHEN Module Diagram.
2022-10-06 Fixed Vreg KAP2112K
2022-10-06 Changed oomp parts format.
2022-10-06 Added an ELLA
2022-10-06 Generated ELLA files.
2022-10-06 Ella update.
2022-10-07 A bit of part harvesting
2022-10-07 Added a few things.
2022-10-07 New farming.
2022-10-07 Projects updating.
2022-10-07 Fixed up readme's
2022-10-08 Part matching changes.
2022-10-08 A bit of part matching
2022-10-09 Worked on readme documenting a bit.
2022-10-10 Full prject run.
2022-10-11 Added new projects.
2022-10-12 Fixed nano schematic typo.
2022-10-12 Fixed schematic.
2022-10-13 Resolutions.
2022-10-14 Added a few project detail files properly.
2022-10-15 Current state of projects?
2022-10-15 Added a bounding box
2022-10-16 Project files
2022-10-16 Project stuff
2022-10-17 Resolutions and readme fixup.
2022-10-17 Projects refresh.
2022-10-17 Tidying up project generation.
2022-10-17 Extra matches.
2022-10-18 Some more matching.
