# Repository oomlout/oomlout_OOMP_projects

File README.md:

# oomlout_OOMP_projects
OOpen Organization Method for parts. This is all the project details.

### Part Files
* Summaries
	Readme's are generated using mdutils (https://github.com/didix21/mdutils). Generation is done in OOMPsummaries.py
	* Readme.md (generated)  --  A summary of the part in markdown.

* Images
	Images also have extra resolutions generated these are, _140, _450, _600.
	* image.jpg  --  Main image.
	* image_RE.jpg  --  Image for size reference (usually beside a sharpened pencil).
	* image_TOP.jpg  --  Image of the top of the part.
	* image_BOTTOM.jpg  --  Image of the bottom of the part.
	
* Diagrams
	Diagrams are generated from tags, they can use templates (templates/diag/), which can use a parts tags as input. These are compiled to a python script that uses the Simple Inkscape Scripting Extension (https://github.com/spakin/SimpInkScr/) to draw and save svgs, these svgs are then used to genearate pngs, dxfs, and pdfs.
	* diagBBLS.py (generated)  --  A diagram for adding a part to a breadboard layout sheet.
	* diagDIAG.py (generated)  --  A diagram for adding a part to a layout.
	* diagIDEN.py (generated)  --  A diagram for adding a part to a PCB with details.
	* diagSCHEM.py (generated)  --  A diagram for adding a part to a schematic.
	* diagSIMP.py (generated)  --  A diagram with only the parts outline, and link.
    * diagFritz.fzpz  --  A diagram in Fritzing format
    * working.cdr  --  A file for working on the component drawing in Corel Draw format

* Datasheets
	* datasheet.pdf  --  Datasheet for the part.
	* datasheet-C-SUPL  --  If more than one datasheet exists the manufacturers four letter code is added.
	* datasheet.txt (generated)  --  If the datasheet is a duplicate this file has the location in it, if it is hosted externally a link.
	
* 3D Models
	3D models are generated programatically these routines are in OOMPscad.py, they use SolidPython (https://github.com/SolidCode/SolidPython) to generate .scad files from which stls and pngs are generated.
	* 3dmodel.scad (generated)  --  Scad model of the part. Programatically generated in OOMPscad.py
	* 3dmodel.stl (generated)  --  STL version of 3dmodel.scad
	* 3dmodel.png (generated)  --  Rendered image of 3dmodel.scad (ortho)
	
* Labels
	Labels are generated using tags and templates these are in templates/label/ they are svgs and use search and replace to generate labels. (%%ID%% is replaced by part ID and tags are format @@%%ID%%,oompPart.oompID,tagName@@). From the svgs pdfs are generated.
	* label-front.svg (generated)  --  A label for the front of a bag.
	* label-inventory.svg (generated)  --  A label for keeping inventory organized.
	* label-spec.svg (generated)  --  A label listing part specifications.

* EDA
    Design files
    * boardEagle.brd  --  Board file in Eagle format
    * schematicEagle.scm  --  Schematic File in Eagle format
    * boardKicad.brd  --  Board file in Kicad format
    * schematicKicad.scm  --  Schematic File in Kicad format

## KiCad design PROJ-SEED-20054-STAN-01/kicad/boardKicad.kicad_pcb

File PROJ-SEED-20054-STAN-01/Readme.md:

Contents
========

* [PRS20054 > ](#prs20054--)
	* [Schematic](#schematic)
	* [Interactive BOM](#interactive-bom)
	* [OOMP Parts](#oomp-parts)
	* [Images](#images)
	* [Tags](#tags)
  
![][im]
# PRS20054 > 

- ID: PROJ-SEED-20054-STAN-01
- Hex ID: PRS20054
- Name: Grove - ADXL345 - 3-Axis Digital Accelerometer(+/-16g)
- Description: Grove - ADXL345 - 3-Axis Digital Accelerometer(+/-16g)
- Long Link: [http://oom.lt/PROJ-SEED-20054-STAN-01](http://oom.lt/PROJ-SEED-20054-STAN-01)
- Short Link: [http://oom.lt/PRS20054](http://oom.lt/PRS20054)

## Schematic

## Interactive BOM

- Interactive BOM page: [ibom.html](https://htmlpreview.github.io/?https://github.com/oomlout/oomlout_OOMP_projects/blob/main/PROJ-SEED-20054-STAN-01/kicad/bom/ibom.html)

## OOMP Parts

|OOMP ID|Name|Identifier|
| :---: | :---: | :---: |
|[CAPC-0805-X-UF10-V10](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0805-X-UF10-V10/)|[SMD (0805) 10 uF Capacitor (Ceramic) 10v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0805-X-UF10-V10/)|[C5, C6](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0805-X-UF10-V10/)|
|UNMATCHED-UNMATCHED-X-UNMATCHED-01||J1, P1, P4, P5, P6, TP1, TP2, TP3, TP4|
|UNMATCHED-SO23-X-UNMATCHED-01||Q1, Q2, U5|
|[RESE-0603-X-O472-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0603-X-O472-01/)|[SMD (0603) 4.7k Ohm Resistor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0603-X-O472-01/)|[R2, R3, R4, R5](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0603-X-O472-01/)|
|[SENS-LG14-X-K345-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/SENS-LG14-X-K345-01/)|[14 Pin SMD (LGA) Digital Accelerometer (ADXL345) Sensor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/SENS-LG14-X-K345-01/)|[U1](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/SENS-LG14-X-K345-01/)|

## Images

|bominteractivefront|bominteractiveback|kicadPcb3d|kicadPcb3dFront|kicadPcb3dBack|eagleSchemImage|
| :---: | :---: | :---: | :---: | :---: | :---: |
|||||||

## Tags

- oompType: PROJ
- oompSize: SEED
- oompColor: 20054
- oompDesc: STAN
- oompIndex: 01
- name: Grove - ADXL345 - 3-Axis Digital Accelerometer(+/-16g)
- gitName: 
- hexID: PRS20054
- oompID: PROJ-SEED-20054-STAN-01
- oompParts: C5,CAPC-0805-X-UF10-V10
- oompParts: C6,CAPC-0805-X-UF10-V10
- oompParts: J1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: P1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: P4,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: P5,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: P6,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: Q1,UNMATCHED-SO23-X-UNMATCHED-01
- oompParts: Q2,UNMATCHED-SO23-X-UNMATCHED-01
- oompParts: R2,RESE-0603-X-O472-01
- oompParts: R3,RESE-0603-X-O472-01
- oompParts: R4,RESE-0603-X-O472-01
- oompParts: R5,RESE-0603-X-O472-01
- oompParts: TP1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: TP2,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: TP3,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: TP4,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: U1,SENS-LG14-X-K345-01
- oompParts: U5,UNMATCHED-SO23-X-UNMATCHED-01
- rawParts: C5,10uF,C-0805,C0805,Ceramic Capacitors,,
- rawParts: C6,10uF,C-0805,C0805,Ceramic Capacitors,,
- rawParts: C7,DNP,CAP-AVX-A,AVX-A,Electrolytic Capacitors,Tantalum Capacitors and Super Capacitors,,
- rawParts: J1,SMD Grove,TWIG-4P-2.0-SMD-FEMALE-REINFORCEDD,4P-SMD-2.0,,,
- rawParts: P1,,PAD-MARKANNULAR,ROUND-MARK-1.0,,DNP,
- rawParts: P2,DNP,PAD60/30,1P-65/35MIL,,,
- rawParts: P3,DNP,PAD60/30,1P-65/35MIL,,,
- rawParts: P4,,PAD-MARKANNULAR,ROUND-MARK-1.0,,DNP,
- rawParts: P5,,PAD-MARKANNULAR,ROUND-MARK-1.0,,DNP,
- rawParts: P6,,PAD-MARKANNULAR,ROUND-MARK-1.0,,DNP,
- rawParts: Q1,2N7002,MOSFET-NSOT23,SOT23,IRLL014:,,
- rawParts: Q2,2N7002,MOSFET-NSOT23,SOT23,IRLL014:,,
- rawParts: R2,4.7K,R-0603,R0603,,,
- rawParts: R3,4.7K,R-0603,R0603,,,
- rawParts: R4,4.7K,R-0603,R0603,,,
- rawParts: R5,4.7K,R-0603,R0603,,,
- rawParts: TP1,,PAD-TEST-POINT4545,TP_4545,,DNP,
- rawParts: TP2,,PAD-TEST-POINT4545,TP_4545,,DNP,
- rawParts: TP3,,PAD-TEST-POINT4545,TP_4545,,DNP,
- rawParts: TP4,,PAD-TEST-POINT4545,TP_4545,,DNP,
- rawParts: U1,ADXL345,ADXL345,LGA14,3-Axis,+/-2g / +/-4g / +/-8g / +/-16g Digital Accelerometer,,
- rawParts: U5,XC6206P252MR-G,XC6206MR,SOT23,LOW ESR Cap.Compatible Positive Voltage Regulators,,

[im]: kicadPcb3d_450.png

Board: 2 copper layers, 100.0 x 101.9 mm, 48 parts (6 on the bottom side), 9 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
C5, C6: 10uF; C0805
C7: DNP; AVX-A
J1: SMD Grove; 4P-SMD-2.0
P1, P4, P5, P6: ROUND-MARK-1.0
P2, P3: DNP; 1P-65_35MIL
Q1, Q2: 2N7002; SOT23
R2, R3, R4, R5: 4.7K; R0603
TP1, TP2, TP3, TP4: TP_4545
U1: ADXL345; LGA14
U5: XC6206P252MR-G; SOT23
U$1: OSHW_FILLX200_NOTEXT
U$3: TWIGLOGO
U$4, U$5, U$6, U$7, U$8, U$9, U$10, U$11, U$12, U$13, U$14, U$15, U$16, U$17, U$18, U$19, U$20, U$21, U$22, U$23: 1U-DIM-W_-DRILL

Connections:
2V5: C6.2, C7.+, Q1.1, Q2.1, R2.2, R4.2, U1.1, U1.6, U1.7, U5.2
GND: C5.2, C6.1, C7.-, J1.4, J1.SS1, J1.SS2, TP1.T, U1.2, U1.4, U1.5, U1.10, U1.12, U5.1
INT1: P2.1, U1.8
INT2: P3.1, U1.9
SCL: J1.1, Q2.3, R5.1, TP4.T
SCL1: Q2.2, R4.1, U1.14
SDA: J1.2, Q1.3, R3.1, TP3.T
SDA1: Q1.2, R2.1, U1.13
VCC: C5.1, J1.3, R3.2, R5.2, TP2.T, U5.3

File PROJ-SEED-20054-STAN-01/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"U$8,U$22,U$19,U$17,U$4,U$11,U$6,U$5,U$21,U$20,U$15,U$13,U$16,U$10,U$12,U$23,U$14,U$7,U$9,U$18";"1U-DIM-W_-DRILL";20;"";;;
2;"P6,P1,P5,P4";"ROUND-MARK-1.0";4;"";;;
3;"R2,R3,R5,R4";"R0603";4;"4.7K";;;
4;"@HOLE3,@HOLE0,@HOLE2,@HOLE1";"";4;"";;;
5;"Q2,Q1";"SOT23";2;"2N7002";;;
6;"U5";"SOT23";1;"XC6206P252MR-G";;;
7;"J1";"4P-SMD-2.0";1;"SMD Grove";;;
8;"P3,P2";"1P-65_35MIL";2;"DNP";;;
9;"C5,C6";"C0805";2;"10uF";;;
10;"C7";"AVX-A";1;"DNP";;;
11;"U1";"LGA14";1;"ADXL345";;;
12;"U$1";"OSHW_FILLX200_NOTEXT";1;"";;;
13;"U$3";"TWIGLOGO";1;"";;;
14;"TP2,TP3,TP1,TP4";"TP_4545";4;"";;;

## KiCad design PROJ-ADAF-1231-STAN-0B/kicad/boardKicad.kicad_pcb

File PROJ-ADAF-1231-STAN-0B/Readme.md:

Contents
========

* [PRA1231B > ](#pra1231b--)
	* [Schematic](#schematic)
	* [PCB](#pcb)
	* [Interactive BOM](#interactive-bom)
	* [OOMP Parts](#oomp-parts)
	* [Images](#images)
	* [Tags](#tags)
  
![][im]
# PRA1231B > 

- ID: PROJ-ADAF-1231-STAN-0B
- Hex ID: PRA1231B
- Name: ADXL345 - Triple-Axis Accelerometer (+-2g/4g/8g/16g) Rev B
- Description: ADXL345 - Triple-Axis Accelerometer (+-2g/4g/8g/16g) Rev B
- Long Link: [http://oom.lt/PROJ-ADAF-1231-STAN-0B](http://oom.lt/PROJ-ADAF-1231-STAN-0B)
- Short Link: [http://oom.lt/PRA1231B](http://oom.lt/PRA1231B)

## Schematic

## PCB

## Interactive BOM

- Interactive BOM page: [ibom.html](https://htmlpreview.github.io/?https://github.com/oomlout/oomlout_OOMP_projects/blob/main/PROJ-ADAF-1231-STAN-0B/kicad/bom/ibom.html)

## OOMP Parts

|OOMP ID|Name|Identifier|
| :---: | :---: | :---: |
|[CAPC-0805-X-NF100-V50](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0805-X-NF100-V50/)|[SMD (0805) 100 nF Capacitor (Ceramic) 50v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0805-X-NF100-V50/)|[C1](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0805-X-NF100-V50/)|
|CAPC-0805-X-UNMATCHED-01||C3|
|[DIOD-S323-X-K4148-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/DIOD-S323-X-K4148-01/)|[SMD (SOD-323) Diode](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/DIOD-S323-X-K4148-01/)|[D1](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/DIOD-S323-X-K4148-01/)|
|[HEAD-I01-X-PI09-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI09-01/)|[2.54 mm 9 Pin Header](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI09-01/)|[JP1](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI09-01/)|
|[MOSN-SO23-X-KBSS138-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/MOSN-SO23-X-KBSS138-01/)|[SMD (SOT-23) BSS138 N-Ch. MOSFET](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/MOSN-SO23-X-KBSS138-01/)|[Q1, Q2](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/MOSN-SO23-X-KBSS138-01/)|
|[RESE-0805-X-O103-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0805-X-O103-01/)|[SMD (0805) 10k Ohm Resistor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0805-X-O103-01/)|[R1, R2, R3, R5, R6, R7](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0805-X-O103-01/)|
|[SENS-LG14-X-K345-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/SENS-LG14-X-K345-01/)|[14 Pin SMD (LGA) Digital Accelerometer (ADXL345) Sensor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/SENS-LG14-X-K345-01/)|[U1](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/SENS-LG14-X-K345-01/)|
|UNMATCHED-SO235-X-UNMATCHED-01||U2|

## Images

|bominteractivefront|bominteractiveback|kicadPcb3d|kicadPcb3dFront|kicadPcb3dBack|kicadSchem|eagleImage|eagleSchemImage|pcbdraw|pcbdrawback|
| :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: |
|||||||||||

## Tags

- oompType: PROJ
- oompSize: ADAF
- oompColor: 1231
- oompDesc: STAN
- oompIndex: 0B
- name: ADXL345 - Triple-Axis Accelerometer (+-2g/4g/8g/16g) Rev B
- gitRepo: https://github.com/adafruit/Adafruit_ADXL345_PCB
- gitName: Adafruit_ADXL345_PCB
- eagleBoard: Adafruit ADXL345 Triple-Axis Accelerometer.brd
- eagleSchem: Adafruit ADXL345 Triple-Axis Accelerometer.sch
- hexID: PRA1231B
- oompID: PROJ-ADAF-1231-STAN-0B
- oompParts: C1,CAPC-0805-X-NF100-V50
- oompParts: C3,CAPC-0805-X-UNMATCHED-01
- oompParts: D1,DIOD-S323-X-K4148-01
- oompParts: JP1,HEAD-I01-X-PI09-01
- oompParts: Q1,MOSN-SO23-X-KBSS138-01
- oompParts: Q2,MOSN-SO23-X-KBSS138-01
- oompParts: R1,RESE-0805-X-O103-01
- oompParts: R2,RESE-0805-X-O103-01
- oompParts: R3,RESE-0805-X-O103-01
- oompParts: R5,RESE-0805-X-O103-01
- oompParts: R6,RESE-0805-X-O103-01
- oompParts: R7,RESE-0805-X-O103-01
- oompParts: U1,SENS-LG14-X-K345-01
- oompParts: U2,UNMATCHED-SO235-X-UNMATCHED-01
- rawParts: C1,0.1uF,CAP_CERAMIC0805-NOOUTLINE,0805-NO,Ceramic Capacitors,,
- rawParts: C3,10ÃÂµF,CAP_CERAMIC0805-NOOUTLINE,0805-NO,Ceramic Capacitors,,
- rawParts: D1,1N4148,DIODE_SOD323MINI,SOD-323_MINI,Diode,,
- rawParts: JP1,,HEADER-1X970MIL,1X09_ROUND_70,PIN HEADER,,
- rawParts: Q1,BSS138,MOSFET-NWIDE,SOT23-WIDE,N-Channel Mosfet,,
- rawParts: Q2,BSS138,MOSFET-NWIDE,SOT23-WIDE,N-Channel Mosfet,,
- rawParts: R1,10K,RESISTOR0805_NOOUTLINE,0805-NO,Resistors,,
- rawParts: R2,10K,RESISTOR0805_NOOUTLINE,0805-NO,Resistors,,
- rawParts: R3,10K,RESISTOR0805_NOOUTLINE,0805-NO,Resistors,,
- rawParts: R5,10K,RESISTOR0805_NOOUTLINE,0805-NO,Resistors,,
- rawParts: R6,10K,RESISTOR0805_NOOUTLINE,0805-NO,Resistors,,
- rawParts: R7,10K,RESISTOR0805_NOOUTLINE,0805-NO,Resistors,,
- rawParts: U$1,FIDUCIAL,FIDUCIAL,FIDUCIAL_1MM,For use by pick and place machines to calibrate the vision/machine, 1mm,,
- rawParts: U$3,FIDUCIAL,FIDUCIAL,FIDUCIAL_1MM,For use by pick and place machines to calibrate the vision/machine, 1mm,,
- rawParts: U$4,MOUNTINGHOLE2.5,MOUNTINGHOLE2.5,MOUNTINGHOLE_2.5_PLATED,Mounting Hole,EXCLUDE,
- rawParts: U$6,MOUNTINGHOLE2.5,MOUNTINGHOLE2.5,MOUNTINGHOLE_2.5_PLATED,Mounting Hole,EXCLUDE,
- rawParts: U1,,ACCEL_ADXL345,LGA14,ADXL345 - Digital 3-Axis Accelerometer (I2C/SPI),,
- rawParts: U2,,VREG_SOT23-5,SOT23-5,SOT23-5 Fixed Voltage Regulators,,

[im]: kicadPcb3d_450.png

Board: 2 copper layers, 24.1 x 19.0 mm, 19 parts (3 on the bottom side), 12 nets.

Parts:
C1: 0.1uF; 0805-NO
C3: 10µF; 0805-NO
D1: 1N4148; SOD-323_MINI
JP1: 1X09_ROUND_70
Q1, Q2: BSS138; SOT23-WIDE
R1, R2, R3, R5, R6, R7: 10K; 0805-NO
U1: LGA14
U2: SOT23-5
U$1, U$3: FIDUCIAL; FIDUCIAL_1MM
U$4, U$6: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$7: ADAFRUIT_TEXT_20MM

Connections:
3.3V: C1.1, JP1.2, Q1.1, Q2.1, R1.2, R2.2, R3.2, U1.1, U1.6, U2.5
CS: D1.C, JP1.4
CS_3V: D1.A, R2.1, U1.7
GND: C1.2, C3.2, JP1.3, R7.1, U1.2, U1.4, U1.5, U2.2
INT1: JP1.5, U1.8
INT2: JP1.6, U1.9
SCL: JP1.9, Q2.3, R6.1
SCL_3V: Q2.2, R1.1, U1.14
SDA/SDIO: JP1.8, Q1.3, R5.1
SDA/SDIO_3V: Q1.2, R3.1, U1.13
SDO/ADDR: JP1.7, R7.2, U1.12
VIN: C3.1, JP1.1, R5.2, R6.2, U2.1, U2.3

File PROJ-ADAF-1231-STAN-0B/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"JP1";"1X09_ROUND_70";1;"";;;
2;"R2,R3,R5,R7,R1,R6";"0805-NO";6;"10K";;;
3;"C3";"0805-NO";1;"10µF";;;
4;"D1";"SOD-323_MINI";1;"1N4148";;;
5;"U$1,U$3";"FIDUCIAL_1MM";2;"FIDUCIAL";;;
6;"U2";"SOT23-5";1;"";;;
7;"Q1,Q2";"SOT23-WIDE";2;"BSS138";;;
8;"U1";"LGA14";1;"";;;
9;"C1";"0805-NO";1;"0.1uF";;;
10;"U$6,U$4";"MOUNTINGHOLE_2.5_PLATED";2;"MOUNTINGHOLE2.5";;;
11;"U$7";"ADAFRUIT_TEXT_20MM";1;"";;;

## KiCad design PROJ-SPAR-9419-STAN-01/kicad/boardKicadERROR.kicad_pcb

Board: 16 copper layers, 47.0 x 27.9 mm, 9 parts (1 on the bottom side), 8 nets.

Parts:
FID1, FID2: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME1: CREATIVE_COMMONS
JP1: 1X08
LOGO1: OSHW-LOGOM; OSHW-LOGO-M
LOGO2: SFE_LOGO_FLAME.2_INCH; SFE_LOGO_FLAME_.2
LOGO3: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
U1: MICRO-SDCARD
U2: microSD Socket; MICROSD_1_1

Connections:
CD/DAT3: JP1.2, U1.CD/DAT3, U2.2
CLK: JP1.6, U1.CLK, U2.5
CMD: JP1.3, U1.CMD, U2.3
DAT0: JP1.7, U1.DAT0, U2.7
DAT1: JP1.8, U1.DAT1, U2.8
DAT2: JP1.1, U1.DAT2, U2.1
GND: JP1.4, U1.GND, U2.6, U2.CD1, U2.CD2, U2.GND1, U2.GND3
VCC: JP1.5, U1.VCC, U2.4

## KiCad design PROJ-ARDU-MICRO-STAN-01/kicad/boardKicad.kicad_pcb

File PROJ-ARDU-MICRO-STAN-01/Readme.md (part):

Contents
========

* [PRARSTAN > ](#prarstan--)
	* [Schematic](#schematic)
	* [PCB](#pcb)
	* [Interactive BOM](#interactive-bom)
	* [OOMP Parts](#oomp-parts)
	* [Images](#images)
	* [Tags](#tags)
  
![][im]
# PRARSTAN > 

- ID: PROJ-ARDU-MICRO-STAN-01
- Hex ID: PRARSTAN
- Name: Arduino Micro
- Description: Arduino Micro
- Long Link: [http://oom.lt/PROJ-ARDU-MICRO-STAN-01](http://oom.lt/PROJ-ARDU-MICRO-STAN-01)
- Short Link: [http://oom.lt/PRARSTAN](http://oom.lt/PRARSTAN)

## Schematic

## PCB

## Interactive BOM

- Interactive BOM page: [ibom.html](https://htmlpreview.github.io/?https://github.com/oomlout/oomlout_OOMP_projects/blob/main/PROJ-ARDU-MICRO-STAN-01/kicad/bom/ibom.html)

## OOMP Parts

|OOMP ID|Name|Identifier|
| :---: | :---: | :---: |
|[CAPC-0402-X-NF100-V10](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-NF100-V10/)|[SMD (0402) 100 nF Capacitor (Ceramic) 10v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-NF100-V10/)|[C1, C2, C6, C9, C10, C11](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-NF100-V10/)|
|CAPX-UNMATCHED-X-UF22-01||C3, C14|
|[CAPC-0402-X-UF1-V63D](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-UF1-V63D/)|[SMD (0402) 1 uF Capacitor (Ceramic) 6.3v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-UF1-V63D/)|[C4, C5, C7](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-UF1-V63D/)|
|[CAPC-0402-X-PF22-V50](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-PF22-V50/)|[SMD (0402) 22 pF Capacitor (Ceramic) 50v](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-PF22-V50/)|[C12, C13](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/CAPC-0402-X-PF22-V50/)|
|DIOD-UNMATCHED-X-UNMATCHED-01||D2|
|UNMATCHED-UNMATCHED-X-UNMATCHED-01||F1, J3, J5, J6, RESET, RP3, T1, T2, U1, U2, Y3|
|[HEAD-I01-X-PI2X03-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI2X03-01/)|[2.54 mm 6 Pin (2x3) Header](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI2X03-01/)|[J4](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/HEAD-I01-X-PI2X03-01/)|
|[LEDS-0805-G-STAN-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-G-STAN-01/)|[SMD (0805) Green LED](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-G-STAN-01/)|[L](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-G-STAN-01/)|
|UNMATCHED-0805-X-UNMATCHED-01||L2|
|[LEDS-0805-L-STAN-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-L-STAN-01/)|[SMD (0805) Blue LED](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-L-STAN-01/)|[ON](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-L-STAN-01/)|
|[RESE-0402-X-O103-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0402-X-O103-01/)|[SMD (0402) 10k Ohm Resistor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0402-X-O103-01/)|[R1, R2, R4, R9](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0402-X-O103-01/)|
|[RESE-0402-X-O102-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0402-X-O102-01/)|[SMD (0402) 1k Ohm Resistor](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0402-X-O102-01/)|[R5, R6, R7, R8](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/RESE-0402-X-O102-01/)|
|[LEDS-0805-Y-STAN-01](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-Y-STAN-01/)|[SMD (0805) Yellow LED](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-Y-STAN-01/)|[RX, TX](https://github.com/oomlout/oomlout_OOMP_parts/tree/main/LEDS-0805-Y-STAN-01/)|
|UNMATCHED-SO23-X-UNMATCHED-01||U4|
|UNMATCHED-0603-X-UNMATCHED-01||Z1, Z2|

## Images

|bominteractivefront|bominteractiveback|kicadPcb3d|kicadPcb3dFront|kicadPcb3dBack|kicadSchem|eagleImage|eagleSchemImage|pcbdraw|pcbdrawback|
| :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: | :---: |
|||||||||||

## Tags

- hexID: PRARSTAN
- oompType: PROJ
- oompSize: ARDU
- oompColor: MICRO
- oompDesc: STAN
- oompIndex: 01
- sources: All source files from https://store.arduino.cc/collections/boards/products/arduino-micro
- linkBuyPage: https://store.arduino.cc/collections/boards/products/arduino-micro
- oompID: PROJ-ARDU-MICRO-STAN-01
- oompParts: C1,CAPC-0402-X-NF100-V10
- oompParts: C2,CAPC-0402-X-NF100-V10
- oompParts: C3,CAPX-UNMATCHED-X-UF22-01
- oompParts: C4,CAPC-0402-X-UF1-V63D
- oompParts: C5,CAPC-0402-X-UF1-V63D
- oompParts: C6,CAPC-0402-X-NF100-V10
- oompParts: C7,CAPC-0402-X-UF1-V63D
- oompParts: C9,CAPC-0402-X-NF100-V10
- oompParts: C10,CAPC-0402-X-NF100-V10
- oompParts: C11,CAPC-0402-X-NF100-V10
- oompParts: C12,CAPC-0402-X-PF22-V50
- oompParts: C13,CAPC-0402-X-PF22-V50
- oompParts: C14,CAPX-UNMATCHED-X-UF22-01
- oompParts: D2,DIOD-UNMATCHED-X-UNMATCHED-01
- oompParts: F1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: J3,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: J4,HEAD-I01-X-PI2X03-01
- oompParts: J5,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: J6,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: L,LEDS-0805-G-STAN-01
- oompParts: L2,UNMATCHED-0805-X-UNMATCHED-01
- oompParts: ON,LEDS-0805-L-STAN-01
- oompParts: R1,RESE-0402-X-O103-01
- oompParts: R2,RESE-0402-X-O103-01
- oompParts: R4,RESE-0402-X-O103-01
- oompParts: R5,RESE-0402-X-O102-01
- oompParts: R6,RESE-0402-X-O102-01
- oompParts: R7,RESE-0402-X-O102-01
- oompParts: R8,RESE-0402-X-O102-01
- oompParts: R9,RESE-0402-X-O103-01
- oompParts: RESET,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RP3,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: RX,LEDS-0805-Y-STAN-01
- oompParts: T1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: T2,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: TX,LEDS-0805-Y-STAN-01
- oompParts: U1,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: U2,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: U4,UNMATCHED-SO23-X-UNMATCHED-01
- oompParts: Y3,UNMATCHED-UNMATCHED-X-UNMATCHED-01
- oompParts: Z1,UNMATCHED-0603-X-UNMATCHED-01
- oompParts: Z2,UNMATCHED-0603-X-UNMATCHED-01
- rawParts: C1,100n,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C2,100n,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C3,22u,CPOL-EUSMCB,SMC_B,POLARIZED CAPACITOR, European symbol,,,,,,,,,
- rawParts: C4,1uF,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C5,1uF,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C6,100n,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C7,1uF,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C9,100n,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C10,100n,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C11,100n,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C12,22pF,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C13,22pF,C-EUC0402,C0402,CAPACITOR, European symbol,,,,,,,,,
- rawParts: C14,22u,CPOL-EUSMCB,SMC_B,POLARIZED CAPACITOR, European symbol,,,,,,,,,
- rawParts: D+,DNP,TPTP-1.00MM,TP-1.00MM,Testpoint,,DNP,DNP,DNP,DNP,DNP,,DNP,
- rawParts: D-,DNP,TPTP-1.00MM,TP-1.00MM,Testpoint,,DNP,DNP,DNP,DNP,DNP,,DNP,
- rawParts: D2,CD1206-S01575,DIODE-MINIMELF,MINIMELF,DIODE,,,,,,,,,
- rawParts: F1,MF-MSMF050-2 500mA,L-EUL1812,L1812,INDUCTOR, European symbol,,,,,,,,,
- rawParts: FRAME1,DNP,A3-FRAME,FRAME,,DNP,DNP,DNP,DNP,DNP,DNP,DNP,DNP,
- rawParts: J3,USB Micro,USB-MICRO-LEGACY,CON2_USB_MICRO_B_AT,,,http://media.digikey.com/pdf/Data%20Sheets/FCI%20PDFs/10118193-0001LF_Webpage.PDF,http://www.digikey.it/product-detail/en/10118193-0001LF/609-4616-2-ND/2785388,609-4616-2-ND,FCI,10118193-0001LF,,USB Micro,
- rawParts: J4,3x2M,PINHD-2X3,2X03,PIN HEADER,,,,,,,,,
- rawParts: J5,HEAD17-NOSS,HEAD17-NOSS,HEAD17-NOSS,,,,,,,,,,
- rawParts: J6,HEAD17-NOSS-1,HEAD17-NOSS-1,HEAD17-NOSS-1,,,,,,,,,,
- rawParts: L,green,LEDCHIPLED_0805,CHIPLED_0805,LED,,,,,,,,,
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
Board: 4 copper layers, 17.8 x 48.3 mm, 51 parts (22 on the bottom side), 47 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
C1, C2, C6, C9, C10, C11: 100n; C0402
C3, C14: 22u; SMC_B
C4, C5, C7: 1uF; C0402
C12, C13: 22pF; C0402
D2: CD1206-S01575; MINIMELF
D+0: DNP; TP-1.00MM
D-0: DNP; TP-1.00MM
F1: MF-MSMF050-2 500mA; L1812
FRAME1: DNP; FRAME
J3: USB Micro; CON2_USB_MICRO_B_AT
J4: 3x2M; 2X03
J5: HEAD17-NOSS
J6: HEAD17-NOSS-1
L0: green; CHIPLED_0805
L2: MH2029-300Y; 0805
ON0: blue; CHIPLED_0805
R1, R2, R4, R9: 10K; R0402
R5, R6, R7, R8: 1K; R0402
RESET0: TS42
RP3: 22R; CAY16
RX0: yellow; CHIPLED_0805
T1: FDN340P/PMV48XP; SOT-23
T2: PMV48XP; SOT-23
TX0: yellow; CHIPLED_0805
U1: ATMEGA32U4-XUMU; QFN44ML7X7
U2: NCP1117-5; SOT223
U4: LP2985-33DBVR; SOT23-DBV
U$37, U$53: DNP; FD-1-1.5
Y3: 16MHz KX-7; CRYSTAL-3.2-2.5
Z1, Z2: CG0603MLC-05E; CT_CN0603

Connections:
3V3: C4.1, J6.16, U4.5
+5V: C2.1, C3.+, C10.1, C11.1, D2.C, J4.2, J6.6, L2.1, R1.1, R5.1, T1.2, T2.3, U1.2, U1.14, U1.24, U1.34, U2.2, U2.4, U4.1, U4.3
+VIN: C1.1, T2.2, U2.3
A0: J6.14, U1.36
A1: J6.13, U1.37
A2: J6.12, U1.38
A3: J6.11, U1.39
A4: J6.10, U1.40
A5: J6.9, U1.41
AREF: C6.1, J6.15, U1.42
AVCC: C7.1, L2.2, U1.44
D0/RX: J5.4, U1.20
D1/TX: J5.3, U1.21
D2/SDA: J5.7, U1.19
D3/SCL: J5.8, U1.18
D4*: J5.9, U1.25
D5*: J5.10, U1.31
D6*: J5.11, U1.27
D7: J5.12, U1.1
D+: D+0.X, J3.P3, RP3.8, Z1.1
D-: D-0.X, J3.P2, RP3.7, Z2.1
GND: C1.2, C2.2, C3.-, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.-, J3.P5, J3.S1, J3.S2, J3.S3, J3.S4, J3.S5, J3.S6, J4.6, J5.6, J6.4, L0.C, ON0.C, R2.1, R4.2, R9.1, RESET0.3, RESET0.4, RESET0.5, RP3.3, RP3.4, RP3.5, RP3.6, RX0.C, TX0.C, U1.5, U1.15, U1.23, U1.35, U1.43, U1.EXP, U2.1, U4.2, Y3.2, Y3.4, Z1.2, Z2.2
HWB: R4.1, U1.33
IO8: J5.13, U1.28
IO9*: J5.14, U1.29
IO10*: J5.15, U1.30
IO11*: J5.16, U1.12
IO12*: J5.17, U1.26
IO13*: J6.17, R8.1, U1.32
MISO: J4.1, J6.2, U1.11
MOSI: J4.4, J5.1, U1.10
unnamed: R7.2, RX0.A
unnamed: ON0.A, R5.2
unnamed: R6.2, TX0.A
unnamed: L0.A, R8.2
RD+: RP3.1, U1.4
RD-: RP3.2, U1.3
RESET: D2.A, J4.5, J5.5, J6.5, R1.2, RESET0.1, RESET0.2, U1.13
RXLED/SS: J5.2, R7.1, U1.8
SCK: J4.3, J6.1, U1.9
TXLED: R6.1, U1.22
UCAP: C5.1, U1.6
VIN: J6.3, R9.2, T1.3, T2.1
VUSB: C9.1, F1.2, R2.2, T1.1, U1.7
VUSBD: C14.+, F1.1, J3.P1
XTAL1: C13.2, U1.17, Y3.3
XTAL2: C12.2, U1.16, Y3.1

File PROJ-ARDU-MICRO-STAN-01/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"J6";"HEAD17-NOSS-1";1;"HEAD17-NOSS-1";;;
2;"J5";"HEAD17-NOSS";1;"HEAD17-NOSS";;;
3;"@HOLE3,@HOLE1,@HOLE0,@HOLE2";"";4;"";;;
4;"R6,R7,R8,R5";"R0402";4;"1K";;;
5;"J3";"CON2_USB_MICRO_B_AT";1;"USB Micro";;;
6;"R4,R1,R9,R2";"R0402";4;"10K";;;
7;"J4";"2X03";1;"3x2M";;;
8;"C5,C7,C4";"C0402";3;"1uF";;;
9;"RESET0";"TS42";1;"TS42";;;
10;"U$37,U$53";"FD-1-1.5";2;"DNP";;;
11;"D-0,D+0";"TP-1.00MM";2;"DNP";;;
12;"L2";"0805";1;"MH2029-300Y";;;
13;"U1";"QFN44ML7X7";1;"ATMEGA32U4-XUMU";;;
14;"TX0,RX0";"CHIPLED_0805";2;"yellow";;;
15;"L0";"CHIPLED_0805";1;"green";;;
16;"C3,C14";"SMC_B";2;"22u";;;
17;"FRAME1";"FRAME";1;"DNP";;;
18;"C12,C13";"C0402";2;"22pF";;;
19;"Y3";"CRYSTAL-3.2-2.5";1;"16MHz KX-7";;;
20;"C9,C2,C1,C6,C11,C10";"C0402";6;"100n";;;
21;"U2";"SOT223";1;"NCP1117-5";;;
22;"T2";"SOT-23";1;"PMV48XP";;;
23;"T1";"SOT-23";1;"FDN340P/PMV48XP";;;
24;"U4";"SOT23-DBV";1;"LP2985-33DBVR";;;
25;"Z2,Z1";"CT_CN0603";2;"CG0603MLC-05E";;;
26;"D2";"MINIMELF";1;"CD1206-S01575";;;
27;"ON0";"CHIPLED_0805";1;"blue";;;
28;"RP3";"CAY16";1;"22R";;;
29;"F1";"L1812";1;"MF-MSMF050-2 500mA";;;

## KiCad design PROJ-ARDU-NANO-EVERY-01/kicad/boardKicad.kicad_pcb

Board: 4 copper layers, 43.2 x 17.8 mm, 58 parts (0 on the bottom side), 49 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
C1: 4n7; 0805-R2013X50N
C2, C7, C8, C10, C11: 100n; 0402-1005X55N
C3, C4: 22u; 0805-R2013X50N
C5, C9: 4u7; 0402-1005X55N
C6: 1u; 0402-1005X55N
D1: PRTR5V; SOT190P230X110-4N
D2: PMEG6020; SODFL3517X110N
D3: DNP; SODFL3517X110N
D+0: DNP; TP-1.00MM
D-0: DNP; TP-1.00MM
DL1, DL3, DL4: YELLOW; LEDC1608X80N-AK
DL2: GREEN; LEDC1608X80N-AK
FD1, FD2: DNP; FD-1-1.5
FRAME1: DNP; FRAME
IC1: MPM3610
J1: -; ZX62-AB-5PA
J2: DNP; 2X03-TP
JP2, JP3: -; 1X15-CASTELL
PB1: PTS820; C&K_PTS820_NO_HOLES
Q1, Q2: BSS138PS; SOT363
R1: 1M; 0402-1005X55N
R2, R3, R12, R13: 330R; 0402-1005X55N
R4, R6, R10: 100k; 0402-1005X55N
R5, R11, R14, R15, R16, R17, R18, R19: 4k7; 0402-1005X55N
R7: 0R; 0402-1005X55N
R8: 19k1; 0402-1005X55N
R9: 39k; 0402-1005X55N
R20: DNP; 0402-1005X55N
U1: ATMEGA4809; TQFP48
U2: AP2112K-3.3; SOT25
U3: ATSAMD11D14A; HVQFN24

Connections:
+3V3: C6.1, C11.2, D3.C, J2.1, JP2.2, Q1.2, Q1.5, Q2.2, R2.2, R5.2, R11.1, R12.2, R13.2, R14.2, R16.2, R18.2, U2.5, U3.24
+5V: C3.1, C8.2, C9.2, C10.2, D2.C, IC1.7, IC1.8, IC1.9, IC1.20, JP2.12, R4.2, R6.2, R15.2, R17.2, R19.2, U1.14, U1.28, U1.42, U2.1, U2.3
A0: JP2.4, U1.23
A1: JP2.5, U1.22
A2: JP2.6, U1.21
A3: JP2.7, U1.20
A4/SDA: JP2.8, U1.36, U1.46
A5/SCL: JP2.9, U1.37, U1.47
A6: JP2.10, U1.24
A7: JP2.11, U1.25
AREF: C5.1, C7.1, JP2.3, U1.27
D2: JP3.5, U1.44
D3~: JP3.6, U1.39
D4: JP3.7, U1.18
D5~: JP3.8, U1.6
D6~: JP3.9, U1.38
D7: JP3.10, U1.45
D8: JP3.11, U1.33
D9~: JP3.12, U1.4
D10~: JP3.13, U1.5
D11_RESET: J2.6, R5.1, U3.18
D11_SWCLK: J2.3, R11.2, U3.19
D11_SWDIO: J2.2, U3.20
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, DL1.C, DL2.C, IC1.3, IC1.12, IC1.13, IC1.14, J1.5, J2.5, JP2.14, JP3.4, PB1.1, PB1.2, PB1.3, PB1.4, PB1.5, R1.1, R8.1, R9.1, U1.15, U1.29, U1.43, U2.2, U3.23, U3.EXP
MISO: JP3.15, U1.31
MOSI: JP3.14, U1.30
unnamed: C1.1, D1.1, J1.6, J1.7, J1.8, J1.9, J1.10, J1.11, R1.2
unnamed: DL2.A, R2.1
unnamed: DL1.A, R3.1
unnamed: IC1.1, R6.1, R8.2
unnamed: IC1.18, R9.2
unnamed: IC1.17, R10.1
unnamed: DL3.A, R12.1
unnamed: DL4.A, R13.1
RESETN: C2.1, JP2.13, JP3.3, PB1.6, R4.1, U1.40
RX0: Q1.6, R17.1, U1.9
RX1: JP3.2, U1.17
RX_D11: DL3.C, Q1.4, R14.1, U3.16
RX_UPDI: R7.2, U3.12
SCK: JP2.1, R3.2, U1.32
TX0: Q1.3, R15.1, U1.8
TX1: JP3.1, U1.16
TX_D11: DL4.C, Q1.1, R16.1, U3.15
TX_UPDI: D3.A, Q2.1, R7.1, R18.1, R20.1, U3.11
UPDI: J2.4, Q2.6, R19.1, R20.2, U1.41
USB_N: D1.3, D-0.X, J1.2, U3.21
USB_P: D1.2, D+0.X, J1.3, U3.22
VIN: C4.1, IC1.16, JP2.15, R10.2
VUSB: D1.4, D2.A, J1.1

File PROJ-ARDU-NANO-EVERY-01/kicad/boardKicadBom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"R16,R19,R14,R5,R17,R18,R15,R11";"0402-1005X55N";8;"4k7";;;
2;"FRAME1";"FRAME";1;"DNP";;;
3;"D3";"SODFL3517X110N";1;"DNP";;;
4;"R4,R6,R10";"0402-1005X55N";3;"100k";;;
5;"C6";"0402-1005X55N";1;"1u";;;
6;"U3";"HVQFN24";1;"ATSAMD11D14A";;;
7;"FD2,FD1";"FD-1-1.5";2;"DNP";;;
8;"@HOLE2,@HOLE1,@HOLE0,@HOLE3";"";4;"";;;
9;"Q1,Q2";"SOT363";2;"BSS138PS";;;
10;"R13,R12,R3,R2";"0402-1005X55N";4;"330R";;;
11;"DL1,DL3,DL4";"LEDC1608X80N-AK";3;"YELLOW";;;
12;"DL2";"LEDC1608X80N-AK";1;"GREEN";;;
13;"U2";"SOT25";1;"AP2112K-3.3";;;
14;"JP3,JP2";"1X15-CASTELL";2;"-";;;
15;"PB1";"C&K_PTS820_NO_HOLES";1;"PTS820";;;
16;"C11,C10,C8,C2,C7";"0402-1005X55N";5;"100n";;;
17;"C4,C3";"0805-R2013X50N";2;"22u";;;
18;"R7";"0402-1005X55N";1;"0R";;;
19;"J2";"2X03-TP";1;"DNP";;;
20;"J1";"ZX62-AB-5PA";1;"-";;;
21;"C9,C5";"0402-1005X55N";2;"4u7";;;
22;"D+0,D-0";"TP-1.00MM";2;"DNP";;;
23;"IC1";"MPM3610";1;"MPM3610";;;
24;"R20";"0402-1005X55N";1;"DNP";;;
25;"D2";"SODFL3517X110N";1;"PMEG6020";;;
26;"D1";"SOT190P230X110-4N";1;"PRTR5V";;;
27;"C1";"0805-R2013X50N";1;"4n7";;;
28;"R9";"0402-1005X55N";1;"39k";;;
29;"R8";"0402-1005X55N";1;"19k1";;;
30;"R1";"0402-1005X55N";1;"1M";;;
31;"U1";"TQFP48";1;"ATMEGA4809";;;

Notices in the files:
parts and their libraries:
THIS WORK IS LICENSED UNDER A CREATIVE COMMONS ATTRIBUTION-SHAREALIKE 4.0 INTERNATIONAL LICENSE.
THIS FILE IS LICENSED UNDER : CC-SA-BY-NC
RELEASED UNDER THE CREATIVE COMMONS ATTRIBUTION SHARE-ALIKE 4.0 LICENSE
HTTPS://CREATIVECOMMONS.ORG/LICENSES/BY-SA/4.0
